Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-08-21T17:43:46
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Aug 21 17:43:46 2019 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{136833E9-7B23-4A08-BAFD-0FF675B32EB1}\ifc * Database version: 5507 * Database creation date: Wed Aug 21 17:43:46 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Aug 21 17:43:46 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Aug 21 17:43:46 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 254021 Hand shower, 254021(2016):254021 Hand shower:392591
In: Level 1
Type - PredefinedType: FAUCET
Type - Dimensions(Type) - NominalDepth: 58.4 mm; NominalHeight: 241.5 mm; NominalWidth: 95.85 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 254021(2016); ConvergoRefNr: 0087-1909-0070-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 22/07/2019
Type - Green Building Properties(Type) - Customs Code: 39249000; EAN Number: 6414150081064; EN Standard: EN 1112; RSK Number: 8275329; VVS Number: 738618314
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/254021; Catalog Drawing URL: http://static.oras.com/catdrw/254021; Dimension Drawing URL: http://static.oras.com/dimdrw/254021; FDV Document URL: http://www.oras.com/datasheet/254021/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/254021; Group: Shower accessories; Manufacturer: Oras; Market: FIN;DNK;LTU;LVA; Model: 254021 Hand shower; Name_en: 254021 Hand shower; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 290 x 115 x 55; Package Weight: 0.29 kg; Product Code: 254021; Product Datasheet: http://www.oras.com/datasheet/254021/en; Product Family: Oras Apollo; Product Image URL: http://static.oras.com/image/254021; Product URL: http://static.oras.com/254021; Type Name: 254021 Hand shower
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Connection Size: G1/2; Installation and Maintenance: http://static.oras.com/manual/254021; Max. Hot Water Supply: 65 kg/K/s3; Shower Spray: Sensitive
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: n/a; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 254021(2016); Features: n/a; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 254021; Name: 254021 Hand shower; ReplacementCost: n/a; Shape: Sculptured; Size: 95x60x240 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 254021; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 254021 Hand shower
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.0428451 m2; Volume: 0.00135172 m3
Identity Data - Mark: 2
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 254021(2016): 254021 Hand shower; Family and Type: 254021(2016): 254021 Hand shower; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 254021(2016): 254021 Hand shower; Type Id: 254021(2016): 254021 Hand shower; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
